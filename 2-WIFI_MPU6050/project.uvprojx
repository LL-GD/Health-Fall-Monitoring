# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\library;.\star;.\user;.\BSP;.\SYSTEM;.\BSP\LCD;.\BSP\LED;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\BSP\ESP8266;.\BSP\OLED;.\BSP\MPU6050;.\BSP\BEEP;.\BSP\UART3;.\BSP\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
  group library
    ./library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group star
    ./star/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_md.s
  group SYSTEM
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/sys/: sys.c sys.h
    ./SYSTEM/usart/: usart.c usart.h
  group BSP
    ./BSP/LED/: led.c led.h
    ./BSP/ESP8266/: esp8266_uart.c esp8266.c esp8266_mqtt.c
    ./BSP/OLED/: OLED.c OLED_Data.c
    ./BSP/BEEP/: beep.c
    ./BSP/UART3/: uart3.c
    ./BSP/TIMER/: timer.c
  group mpu6050
    ./BSP/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c
